Commit message: update

File: install/my_box_bot_gazebo/share/my_box_bot_gazebo/urdf/final_urdf.urdf (robot description, URDF)
Before this commit: robot final_urdf, 6 links, 5 joints
Links:
- added link world_link
Joints:
- added joint dummy_joint: type fixed, parent world_link, child base_link
